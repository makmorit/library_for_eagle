# Repository makmorit/library_for_eagle

## EAGLE design SampleBoard/CX60-24S-UNIT.brd

Parts:
CN1: CX60-24S-UNIT
CN2: 87520-0010BLF
CN3: IF_5PIN_H; HEADER_5PIN
R1: 5.1k; R0402

Connections:
0V: CN1.A1 (GND1_A), CN1.A12 (GND2_A), CN1.B1 (GND1_B), CN1.B12 (GND2_B), CN2.GND, CN3.1, R1.1
DN_C: CN1.A7 (D_N), CN2.D-, CN3.2
DP_C: CN1.A6 (D_P), CN2.D+, CN3.3
FG_C: CN1.AFG (FG_A), CN1.BFG (FG_B), CN2.FG1, CN2.FG2, CN3.5
unnamed: CN1.A5 (CC), R1.2
VBUS_C: CN1.A4 (VBUS1_A), CN1.A9 (VBUS2_A), CN1.B4 (VBUS1_B), CN1.B9 (VBUS2_B), CN2.VBUS, CN3.4

Board: 2 copper layers, 30.4 x 30.4 mm, 4 parts (0 on the bottom side), 6 nets.

## EAGLE design STM32F7_eval/STM32F767ZI_eval_1.brd

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C17, C18, C19, C41: 0.1uF; SMD_1608_DEV
C13, C14: 2pF; SMD_1608_DEV
C15, C16: 4.3pF; SMD_1608_DEV
C20, C21: 2.2uF X7R; C1206
C22: 4.7uF; SMD_2012_DEV
C23, C40: 1uF X5R; SMD_1608_DEV
C24: 10uF; C1210_TPST_DEV
C25: 1uF; SMD_1608_DEV
D1, D2, D3, D4: LED_0805; CHIPLED_0805
FB1: BLM21PG300SN1D; SMD_2012_DEV
R1, R2, R3, R4, R9, R10: 0; SMD_1608_DEV
R6: 300; SMD_1608_DEV
R7, R18: 200k; SMD_1608_DEV
R8, R17: 10k; SMD_1608_DEV
R13: 680; SMD_1608_DEV
R14, R16: 1k; SMD_1608_DEV
R15: 510; SMD_1608_DEV
SW1, SW2: SKRPACE010_; SKRPACE010_DEV
U1: STM32F767ZI_; LQFP144_DEV
U2: LD39050PU33R_DEV; DFN6-3X3_
U4: TSV631AICT_; SC-70-5_DEV
X1: NX3215SA_; NX3215_DEV
X2: NX3225GD_; NX3225_DEV

Connections:
0V: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2 (-), C25.2, C40.2, C41.2, D1.C, D2.C, D3.C, D4.C, R7.1, R8.2, R9.1, R18.1, SW1.3 (S), SW1.4 (S1), U1.16 (VSS0), U1.38 (VSS2), U1.51 (VSS3), U1.61 (VSS4), U1.83 (VSS6), U1.94 (VSS7), U1.107 (VSS8), U1.120 (VSS9), U1.130 (VSS10), U2.2 (GND), U2.EXP (GND0), U4.2 (V-); also elsewhere on the board
+3V3: C40.1, C41.1, R10.1, U2.4 (VOUT), U4.5 (V+); also elsewhere on the board
AGND: C19.2, R9.2, U1.31 (VSSA)
AVDD: C19.1, FB1.2, U1.32 (VREF+), U1.33 (VDDA); also elsewhere on the board
BOOT0: R8.1, U1.138 (BOOT0)
LED1: R15.2, U4.3 (IN-), U4.4 (OUT)
unnamed: C15.1, R3.1, X2.1
unnamed: C14.1, R2.1, X1.2
unnamed: C13.1, R1.1, X1.1
unnamed: D2.A, R13.1
unnamed: C16.1, R4.1, X2.2
unnamed: R6.2, R7.2, SW2.1, SW2.2 (P1)
unnamed: D3.A, R14.1
unnamed: R17.2, R18.2, U4.1 (IN+)
unnamed: D1.A, R15.1
unnamed: D4.A, R16.1
NRST: C17.1, SW1.1, SW1.2 (P1), U1.25 (NRST); also elsewhere on the board
PA3: U1.37 (PA3); also elsewhere on the board
PA5: U1.41 (PA5); also elsewhere on the board
PA6: U1.42 (PA6); also elsewhere on the board
PA7: U1.43 (PA7); also elsewhere on the board
PA15: U1.110 (PA15); also elsewhere on the board
PB0: R17.1, U1.46 (PB0)
PB7: R13.2, U1.137 (PB7)
PB8: U1.139 (PB8); also elsewhere on the board
PB9: U1.140 (PB9); also elsewhere on the board
PB10: U1.69 (PB10); also elsewhere on the board
PB11: U1.70 (PB11); also elsewhere on the board
PB14: R14.2, U1.75 (PB14)
PC0: U1.26 (PC0); also elsewhere on the board
PC10: U1.111 (PC10); also elsewhere on the board
PC11: U1.112 (PC11); also elsewhere on the board
PC12: U1.113 (PC12); also elsewhere on the board
PC13: R6.1, U1.7 (PC13)
PC14: R2.2, U1.8 (PC14)
PC15: R1.2, U1.9 (PC15)
PD8: U1.77 (PD8); also elsewhere on the board
PD9: U1.78 (PD9); also elsewhere on the board
PD14: U1.85 (PD14); also elsewhere on the board
PD15: U1.86 (PD15); also elsewhere on the board
PE0: U1.141 (PE0); also elsewhere on the board
PE1: U1.142 (PE1); also elsewhere on the board
PE9: U1.60 (PE9); also elsewhere on the board
PE11: U1.64 (PE11); also elsewhere on the board
PE13: U1.66 (PE13); also elsewhere on the board
PE15: U1.68 (PE15); also elsewhere on the board
PF12: U1.50 (PF12); also elsewhere on the board
PF13: U1.53 (PF13); also elsewhere on the board
PF14: U1.54 (PF14); also elsewhere on the board
PF15: U1.55 (PF15); also elsewhere on the board
PG9: U1.124 (PG9); also elsewhere on the board
PG14: U1.129 (PG14); also elsewhere on the board
PH0: R4.2, U1.23 (PH0)
PH1: R3.2, U1.24 (PH1)
SWO: U1.133 (PB3); also elsewhere on the board
TCK: U1.109 (PA14); also elsewhere on the board
TMS: U1.105 (PA13); also elsewhere on the board
VCAP_1: C20.1, U1.71 (VCAP_1)
VCAP_2: C21.1, U1.106 (VCAP_2)
VDD: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C22.1, C25.1, FB1.1, R10.2, SW2.3 (S), SW2.4 (S1), U1.6 (VBAT), U1.17 (VDD0), U1.30 (VDD1), U1.39 (VDD2), U1.52 (VDD3), U1.62 (VDD4), U1.72 (VDD5), U1.84 (VDD6), U1.95 (VDDUSB), U1.108 (VDD8), U1.121 (VDDSDMMC), U1.131 (VDD10), U1.143 (PDR_ON), U1.144 (VDD11); also elsewhere on the board
VIN: C18.1, C23.1, C24.1 (+), R16.2, U2.1 (EN), U2.6 (VIN); also elsewhere on the board

Notes on the sheet:
OSC_OUT
OSC_IN
ユーザーボタン回路
リセットボタン回路
低ESRのセラミックコンデンサーを VCAP_1/VCAP_2に接続
メインデバイス配線図
電源回路（入力は4.5V〜5.0V想定）
赤色LED
青色LED
緑色LED
水晶発振回路（8MHz、32.768KHz）
LEDインジケーター回路
OSC32_OUT
OSC32_IN
1uFは VBATの近傍に設置
1uF/0.1uFは LDOのVOUT近傍に設置

Parts:
CN1: STLINKV2_SWD_IF_; DF65-7P-1.7V_DEV
CN2, CN3: GROVE-4P-CONN-I2C-90D; GROVE-4P-90D
CN5: ARDUINO_COMPAT_IF
R20, R26: 0; SMD_1608_DEV

Connections:
0V: CN1.2 (GND), CN2.4 (GND), CN3.4 (GND), CN5.15 (GND0), CN5.24 (GND1), CN5.25 (GND2); also elsewhere on the board
+3V3: CN2.3 (VCC), CN3.3 (VCC), CN5.20 (IOREF), CN5.22 (+3V3); also elsewhere on the board
AVDD: CN5.16 (AVDD); also elsewhere on the board
NRST: CN1.4 (NRST), CN5.21 (NRST); also elsewhere on the board
PA3: CN5.27 (A0); also elsewhere on the board
PA5: CN5.14 (D13_SPI_SCLK); also elsewhere on the board
PA6: CN5.13 (D12_SPI_MISO); also elsewhere on the board
PA7: CN5.12 (D11_SPI_MOSI); also elsewhere on the board
PB8: CN2.1 (SCL), CN3.1 (SCL), CN5.18 (D15_I2C_SCL); also elsewhere on the board
PB9: CN2.2 (SDA), CN3.2 (SDA), CN5.17 (D14_I2C_SDA); also elsewhere on the board
PC0: CN5.28 (A1); also elsewhere on the board
PD8: CN1.6 (RX); also elsewhere on the board
PD9: CN1.7 (TX); also elsewhere on the board
PD14: CN5.11 (D10); also elsewhere on the board
PD15: CN5.10 (D9); also elsewhere on the board
PE0: R26.2; also elsewhere on the board
PE1: R20.2; also elsewhere on the board
PE9: CN5.7 (D6); also elsewhere on the board
PE11: CN5.6 (D5); also elsewhere on the board
PE13: CN5.4 (D3); also elsewhere on the board
PF12: CN5.9 (D8); also elsewhere on the board
PF13: CN5.8 (D7); also elsewhere on the board
PF14: CN5.5 (D4); also elsewhere on the board
PF15: CN5.3 (D2); also elsewhere on the board
PG9: CN5.1 (D0); also elsewhere on the board
PG14: CN5.2 (D1); also elsewhere on the board
RX_AUX: CN5.31 (A4), R26.1
SWO: CN1.5 (SWO); also elsewhere on the board
TCK: CN1.1 (JTCK); also elsewhere on the board
TMS: CN1.3 (JTMS); also elsewhere on the board
TX_AUX: CN5.32 (A5), R20.1
VIN: CN5.23 (+5V), CN5.26 (VIN); also elsewhere on the board

Notes on the sheet:
外部I/Fコネクター配線図
Groveコネクター ・I2Cポート x 2
Arduino互換ピン
ST-LINK V2-1 インターフェース用ピン
通信モジュールメンテナンス用UART 接続用ジャンパー
ジャンパーを実装すると、 A4＝RX（PE0）、A5＝TX（PE1） に転化します。

Parts:
C26, C38: 0.1uF; SMD_1608_DEV
C27, C30, C33, C34, C35, C36: 10uF; SMD_2012_DEV
C31, C32: 1uF; SMD_2012_DEV
C37: 4.7uF; SMD_2012_DEV
C39: 10uF; C1210_TPST_DEV
CN7: WFT0750CZ09-SMD_; FH12A-24S-0.5SH_DEV
D5, D6, D7: MBR0530_; MBR0530_DEV
L1: 10uH; NLCV25T_DEV
Q1: PMF370XN_; SOT323_DEV
R11, R12: 3.3k; SMD_2012_DEV
R21: 10k; SMD_1608_DEV
R22: 0.47; SMD_2012_DEV
R23: 100k; SMD_2012_DEV
R24: 0; SMD_1608_DEV
U3: LM75BIMM-3_; SSOP8-DGK_DEV

Connections:
0V: C26.2, C27.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C38.2, C39.2 (-), CN7.8 (BS1), CN7.17 (VSS), D6.1 (C), R21.1, R22.1, R23.1, U3.4 (GND), U3.5 (A2), U3.6 (A1), U3.7 (A0); also elsewhere on the board
+3V3: R24.1; also elsewhere on the board
GDR: CN7.2 (GDR), Q1.1 (G), R23.2
unnamed: CN7.1 (MFCSB), R21.2
unnamed: C37.1, D5.2 (A), L1.2, Q1.3 (D)
unnamed: C37.2, D6.2 (A), D7.1 (C)
PA5: CN7.13 (D0/SCLK); also elsewhere on the board
PA7: CN7.14 (D1/SDAT); also elsewhere on the board
PD14: CN7.12 (CS#); also elsewhere on the board
PD15: CN7.11 (D/C#); also elsewhere on the board
PF12: CN7.10 (RES#); also elsewhere on the board
PREVGH: C35.1, CN7.21 (PREVGH), D5.1 (C)
PREVGL: C36.1, CN7.23 (PREVGL), D7.2 (A)
RESE: CN7.3 (RESE), Q1.2 (S), R22.2
TSCL: CN7.6 (TSCL), R11.1, U3.2 (SCL)
TSDA: CN7.7 (TSDA), R12.1, U3.1 (SDA)
VCC_EPD: C26.1, C38.1, C39.1 (+), CN7.15 (VDDIO), CN7.16 (VCI), L1.1, R11.2, R12.2, R24.2, U3.8 (+VS)
VCOM: C31.1, CN7.24 (VCOM)
VDD_CAP: C32.1, CN7.18 (VDD)
VGH: C27.1, CN7.5 (VGH)
VGL: C30.1, CN7.4 (VGL)
VSH: C33.1, CN7.20 (VSH)
VSL: C34.1, CN7.22 (VSL)

Notes on the sheet:
オプションデバイス配線図
VGL／VGHの定数は、 EPDのサイズに応じて下記を選択のこと。 7.5inch - 10uF 4.2inch - 4.7uF 2.9inch - 1uF
PREVGL／PREVGH／VSH／VSLの定数は、 EPDのサイズに応じて下記を選択のこと。 7.5inch - 10uF 4.2inch - 4.7uF 2.9inch - 1uF
EPD接続インターフェース回路図

Parts:
C28, C49: 1uF X5R; SMD_1608_DEV
C29: 10uF; C1210_TPST_DEV
C42, C45, C46: 0.1uF; SMD_1608_DEV
R5: 10k; SMD_1608_DEV
R19: 10; SMD_1608_DEV
R25: 0; SMD_1608_DEV
U5: MIC5366-1.8YC5_; SC-70-5_DEV
U6: MX25U6435F; SOP_8L
U7: FXMA108_; DQFN20_DEV

Connections:
0V: C28.2, C29.2 (-), C42.2, C45.2, C46.2, C49.2, R5.1, U5.2 (GND), U6.4 (GND), U7.10 (GND); also elsewhere on the board
!CS!: U6.1 (!CS), U7.3 (A1)
!OE!: R5.2, U7.11 (!OE!)
+1V8: C28.1, C29.1 (+), C42.1, C45.1, U5.5 (VOUT), U6.3 (!WP!/SIO2), U6.7 (!RESET!/SIO3), U6.8 (VCC), U7.1 (VCCA)
+3V3: R25.1; also elsewhere on the board
PA15: U7.18 (B1); also elsewhere on the board
PC10: R19.2; also elsewhere on the board
PC10_D: R19.1, U7.16 (B3)
PC11: U7.14 (B5); also elsewhere on the board
PC12: U7.12 (B7); also elsewhere on the board
SCLK: U6.6 (SCLK), U7.5 (A3)
SI: U6.5 (SI/SIO0), U7.9 (A7)
SO: U6.2 (SO/SIO1), U7.7 (A5)
VCC_MEM: C46.1, C49.1, R25.2, U5.1 (VIN), U5.3 (EN), U7.20 (VCCB)

Notes on the sheet:
オプションデバイス配線図
セラミックコンデンサーを VCCピンの近傍に設置
!CS!に LOW を出力時は フラッシュが使用可能
!RESET!はHIGH固定
!OE!に LOW を出力時は FXMA108のバスが 使用可能になる
1uFはVINピンの 近傍に設置
フラッシュメモリー回路図
SPI_3 を使用 ・PA15 = !CS! ・PC10 = SPI_SCLK ・PC11 = SPI_MISO ・PC12 = SPI_MOSI
1uFはVOUTピンの 近傍に設置
SPIクロック信号の ダンピング用抵抗

Parts:
C47: 0.1uF; SMD_1608_DEV
C48: 10uF; SMD_2012_DEV
R27, R28: 2.2k; SMD_1608_DEV
R29: 0; SMD_1608_DEV
U9: STSAFE; SO8N

Connections:
0V: C47.2, C48.2, U9.4 (GND); also elsewhere on the board
PB10: R27.1, U9.7 (SCL); also elsewhere on the board
PB11: R28.1, U9.5 (SDA); also elsewhere on the board
PE15: U9.1 (!RESET!); also elsewhere on the board
VCC_STSAFE: C47.1, C48.1, R27.2, R28.2, R29.2, U9.2 (VCC)
VDD: R29.1; also elsewhere on the board

Notes on the sheet:
オプションデバイス配線図
セキュリティーチップ回路図
I2C_2 を使用 ・PB10 = I2C_SCL ・PB11 = I2C_SDA

Board: 2 copper layers, 76.2 x 53.3 mm, 103 parts (57 on the bottom side), 88 nets.

## EAGLE design SampleBoard/MX25U6435F_eval_0.brd

Parts:
C23, C43: 1uF X5R; SMD_1608_DEV
C24: 10uF; C1210_TPST_DEV
C42, C45, C46: 0.1uF; SMD_1608_DEV
CN1: MX25U_IF_6PIN; HEADER_6PIN
R5: 10k; SMD_1608_DEV
R25: 0; SMD_1608_DEV
U1: MIC5366-1.8YC5_; SC-70-5_DEV
U6: MX25U6435F; SO8
U7: FXMA108_; DQFN20_DEV

Connections:
0V: C23.2, C24.2 (-), C42.2, C43.2, C45.2, C46.2, CN1.6 (GND), R5.1, U1.2 (GND), U6.4 (GND), U7.10 (GND)
!CS!: U6.1 (!CS), U7.3 (A1)
!OE!: R5.2, U7.11 (!OE!)
+1V8: C23.1, C24.1 (+), C42.1, C45.1, U1.5 (VOUT), U6.3 (!WP!/SIO2), U6.7 (!RESET!/SIO3), U6.8 (VCC), U7.1 (VCCA)
+3V3: CN1.1 (+3V3), R25.1
PA15: CN1.2 (PA15), U7.18 (B1)
PC10: CN1.5 (PC10), U7.16 (B3)
PC11: CN1.4 (PC11), U7.14 (B5)
PC12: CN1.3 (PC12), U7.12 (B7)
SCLK: U6.6 (SCLK), U7.5 (A3)
SI: U6.5 (SI/SIO0), U7.9 (A7)
SO: U6.2 (SO/SIO1), U7.7 (A5)
VCC_MEM: C43.1, C46.1, R25.2, U1.1 (VIN), U1.3 (EN), U7.20 (VCCB)

Notes on the sheet:
NORフラッシュ回路図
セラミックコンデンサーを VCCピンの近傍に設置
!CS! = LOW 時は フラッシュ使用可
!RESET!はHIGH固定
!OE!に LOW を出力時は FXMA108のバスが 使用可能になる
SPI_3 を使用 ・!CS! = PA15 ・SPI_MOSI = PC12 ・SPI_MISO = PC11 ・SPI_SCLK = PC10

Board: 2 copper layers, 19.1 x 25.4 mm, 12 parts (8 on the bottom side), 13 nets.

## EAGLE design ADM3202_eval/ADM3202_conv.brd

Parts:
C1, C2, C3, C4, C5: 0.1uF; SMD_2012_DEV
CN1: UART_IF_6PIN
CN2: RS_232C_IF; UM04_RS_232C_IF_9PIN
CN3: POWER_IF_3V3; HEADER_2PIN_3V3_IF
R1: 33; RESISTOR_0207_300MIL
R2, R3: 10k; SMD_2012_DEV
S1: SS12D01G4; SLIDE_SWITCH_1C
U1: ADM3202AN; DIL16

Connections:
0V: C3.2, C5.2, CN1.2 (GND), CN2.5 (SG), CN3.1 (GND), R3.1, S1.1 (O), U1.15 (GND)
+3V3: C4.1, C5.1, CN1.1 (VCC), CN3.2 (VDD), S1.3 (S), U1.16 (VCC)
CTS: CN2.8 (CS), R1.1
MODE_SW: CN1.6 (MODE_SW), R2.1
unnamed: C1.2, U1.3 (C1-)
unnamed: C1.1, U1.1 (C1+)
unnamed: CN2.3 (SD), U1.14 (T1OUT)
unnamed: C3.1, U1.6 (V-)
unnamed: C2.1, U1.4 (C2+)
unnamed: C2.2, U1.5 (C2-)
unnamed: C4.2, U1.2 (V+)
unnamed: CN2.2 (RD), U1.13 (R1IN)
unnamed: CN1.3 (RX1), U1.12 (R1OUT)
unnamed: CN1.4 (TX1), U1.11 (T1IN)
unnamed: R3.2, U1.9 (R2OUT)
unnamed: CN1.5 (DTR), U1.10 (T2IN)
unnamed: CN2.4 (ER), U1.7 (T2OUT)
unnamed: CN2.6 (DR), U1.8 (R2IN)
unnamed: R2.2, S1.2
RTS: CN2.7 (RS), R1.2

Board: 2 copper layers, 35.0 x 37.0 mm, 13 parts (0 on the bottom side), 20 nets.
